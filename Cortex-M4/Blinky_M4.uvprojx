# Keil uVision project Blinky_M4.uvprojx, settings and files
target CMSIS-RTOS Blinky (6230000::V6.23::ARMCLANG)
  device: MCIMX7D7:Cortex-M4 NXP
  pack: Keil.iMX7D_DFP.1.7.8
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x1FFF0000,0x00008000) IROM(0x00000000,0x00008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: Blinky_M4
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  library: MicroLIB
  memory RVCT4: ROM 0x1fff8000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fff0000 size 0x8000
  group Sources
    ./: main.c
software components: CMSIS:CORE 6.1.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:Keil RTX5 5.9.0, Board Support:HW INIT 1.0.0, Board Support:User I/O Redirect 1.0.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Compiler:I/O:TTY 1.2.0, Device:Startup 1.0.0, Device:iMX7D HAL:CCM 1.0.0, Device:iMX7D HAL:RDC 1.0.0, Device:iMX7D HAL:UART 1.0.0
